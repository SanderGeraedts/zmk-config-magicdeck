## boards/shields/sg_magicdeck/Kconfig.defconfig
```kconfig
if SHIELD_SG_MAGICDECK

config ZMK_KEYBOARD_NAME
    default "SG MagicDeck"

endif
```
